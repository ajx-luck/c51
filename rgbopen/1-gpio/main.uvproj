# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: WS51F6030 WS51
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0x1FF) CLOCK(16000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HeadFile
  group Source Group 1
    ./: STARTUP.A51 main.c WS51F7030.c nvr.c user.h
